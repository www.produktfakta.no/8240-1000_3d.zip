Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X_PLATFORM
File name: Default Project
Time: 2011-01-07T18:17:35
Written by: Revit Architecture 2009 - 1.0
Made in: 20080321_1900

# IfcSite, Default
RefLatitude: 42, 12, 46, 800000; RefLongitude: -71, -1, -58, -800000; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
Elevation: 0 mm
PSet_Revit_Identity Data - Name: Level 1
PSet_Revit_Constraints - Elevation: 0 mm
PSet_Revit_Type_Graphics - Line Weight: 1; Color: 0; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
PSet_Revit_Type_Constraints - Elevation Base: 0
PSet_Revit_Type_Dimensions - Automatic Room Computation Height: no; Computation Height: 1200 mm

# IfcBuildingElementProxy: FMM 82401000, 82401000_IFC:FMM 82401000:FMM 82401000:106225
In: Level 1
PSet_Revit_Dimensions - Mounting Height: 700 mm
PSet_Revit_Constraints - Host: Level : Level 1; Offset: 0 mm; Moves With Nearby Elements: no
PSet_Revit_Identity Data - Mark: 1
PSet_Revit_Type_Identity Data - VVS: -; URL: www.fmmattsson.com; RSK: 8343247; NRF: -; Model: 8240-1000; Manufacturer: FM Mattsson; LVI: -; Family: FM 9000E Bla; EAN: 7391887228759; Description: Safety Mixer For Bath / 40 c/c, Chrome
